# Repository ms0503/circuit-esp32-base

File README.md:

# Everyday Shumai Party

Everyday Shumai PartyはEspressif社の評価ボード「ESP32-DevKitC-32E」から
各種コネクタにアクセスできるようにする、いわゆる下駄基板です。

## 対応コネクタ

仙台高専名取キャンパスメカトロニクス研究部会の規格に準拠しています。

(ピンアサインはコネクタのピン番号順)

| シンボル# |   コネクタ名    |         用途         |        ピンアサイン        | 個数 |
| :-------: | :-------------: | :------------------: | :------------------------: | ---: |
|    J1     |  XH 3ピン オス  |     12V・5V電源      |      `12V` `5V` `GND`      |    1 |
|   J2-3    | DF1B 4ピン オス |         UART         |    `RX` `TX` `GND` `5V`    |    2 |
|   J4-5    |  XA 4ピン オス  |         CAN          | `5V` `CAN_P` `CAN_N` `GND` |    2 |
|   J6-11   |  XA 3ピン オス  |      PWM MD・IO      |      `IO` `IO` `GND`       |    6 |
|    J12    |  QI 4ピン オス  |  入力・アナログ入力  |          `IN` x4           |    1 |
|    J13    |  QI 8ピン オス  | 入出力・アナログ入力 |          `IO` x8           |    1 |
|    J14    |  QI 6ピン オス  |        入出力        |          `IO` x6           |    1 |
|  J15-18   |  XH 2ピン オス  |       12V出力        |        `12V` `OUT`         |    4 |

## ピン番表

| GPIO# |         接続先         |
| ----: | :--------------------: |
|     0 |     J13(\#1)・J15      |
|     1 |          N/C           |
|     2 |     J13(\#2)・J16      |
|     3 |          N/C           |
|     4 | J6(\#2)・J13(\#3)・J17 |
|     5 |   J6(\#1)・J14(\#1)    |
|     6 |          N/C           |
|     7 |          N/C           |
|     8 |          N/C           |
|     9 |          N/C           |
|    10 |          N/C           |
|    11 |          N/C           |
|    12 | J7(\#2)・J13(\#4)・J18 |
|    13 |   J8(\#2)・J13(\#5)    |
|    14 |   J9(\#2)・J13(\#6)    |
|    15 |   J10(\#2)・J13(\#7)   |
|    16 |   J7(\#1)・J14(\#2)    |
|    17 |   J8(\#1)・J14(\#3)    |
|    18 |   J9(\#1)・J14(\#4)    |
|    19 |   J10(\#1)・J14(\#5)   |
|    20 |         (N/A)          |
|    21 |   J11(\#1)・J14(\#6)   |
|    22 |         CAN RX         |
|    23 |         CAN TX         |
|    24 |         (N/A)          |
|    25 |        J3(\#1)         |
|    26 |        J3(\#2)         |
|    27 |   J11(\#2)・J13(\#8)   |
|    28 |         (N/A)          |
|    29 |         (N/A)          |
|    30 |         (N/A)          |
|    31 |         (N/A)          |
|    32 |        J2(\#1)         |
|    33 |        J2(\#2)         |
|    34 |        J12(\#1)        |
|    35 |        J12(\#2)        |
|    36 |        J12(\#3)        |
|    37 |         (N/A)          |
|    38 |         (N/A)          |
|    39 |        J12(\#4)        |

## 既知の問題

### v1

- CANトランシーバのフットプリントを間違えている(小さいものとなっている)  
  →v2にて修正
- フットプリントと本来のコネクタの向きを間違えている
- リセット用タクトスイッチの向きを間違えている

### v2

- フットプリントと本来のコネクタの向きを間違えている
- リセット用タクトスイッチの向きを間違えている

## KiCad design circuit-esp32-base.kicad_pcb

Parts:
C1, C2: 0.1uF; C_0603_1608Metric
D1, D2, D3, D4: LED; LED_0603_1608Metric
J1: PWR; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J2: UART1; DF1B-4P-2.5DSA
J3: UART2; DF1B-4P-2.5DSA
J4: CAN_1; JST_XA_B04B-XASK-1_1x04_P2.50mm_Vertical
J5: CAN_2; JST_XA_B04B-XASK-1_1x04_P2.50mm_Vertical
J6: PWM1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J7: PWM2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J8: PWM3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J9: PWM4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J10: PWM5; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J11: PWM6; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J12: IN; 4pin
J13: IO_PWM; 8pin
J14: DIO_PWM; 6pin
J15: 12VIO_1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J16: 12VIO_2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J17: 12VIO_3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J18: 12VIO_4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R1, R2, R3, R4: 510Ω; R_0603_1608Metric
SW1: RESET; tact
SW2, SW3, SW4, SW5: SW_SPST; toggle_1-2
U1: ESP32-DevKitC-32E
U2: MCP2542WFDxMF; DFN-8-1EP_6x5mm_P1.27mm_EP2x2mm
U3: ULN2801A; DIP-18_W7.62mm

Connections:
12VIO_1: J15.2, R1.2, U3.18 (O1)
12VIO_2: J16.2, R2.2, U3.17 (O2)
12VIO_3: J17.2, R3.2, U3.16 (O3)
12VIO_4: J18.2, R4.2, U3.15 (O4)
+3V3: C1.1, U1.1 (3V3), U2.5 (VIO)
+5V: C2.1, J1.2, J2.1, J3.1, J4.1, J5.1, U1.19 (5V), U2.3 (VDD)
+12V: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), J1.1, J15.1, J16.1, J17.1, J18.1, U3.10 (COM)
CAN_N: J4.3, J5.3, U2.6 (CANL)
CAN_P: J4.2, J5.2, U2.7 (CANH)
DIO_5: J6.3, J14.1, U1.29 (IO5)
DIO_16: J7.3, J14.2, U1.31 (IO16)
DIO_17: J8.3, J14.3, U1.30 (IO17)
DIO_18: J9.3, J14.4, U1.28 (IO18)
DIO_19: J10.3, J14.5, U1.27 (IO19)
DIO_21: J11.3, J14.6, U1.25 (IO21)
GND: C1.2, C2.2, J1.3, J2.2, J3.2, J4.4, J5.4, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, SW1.1, SW1.2, SW2.~1, SW2.~2, SW3.~1, SW3.~2, SW4.~1, SW4.~2, SW5.~1, SW5.~2, U1.14 (GND), U1.20 (GND), U1.26 (GND), U2.2 (VSS), U2.8 (STBY), U2.9 (VSS), U3.9 (GND)
IN_34: J12.1, U1.5 (IO34)
IN_35: J12.2, U1.6 (IO35)
IN_36: J12.3, U1.3 (VP)
IN_39: J12.4, U1.4 (VN)
IO_0: J13.1, SW2.2 (B), U1.33 (IO0)
IO_2: J13.2, SW3.2 (B), U1.34 (IO2)
IO_4: J6.2, J13.3, SW4.2 (B), U1.32 (IO4)
IO_12: J7.2, J13.4, SW5.2 (B), U1.13 (IO12)
IO_13: J8.2, J13.5, U1.15 (IO13)
IO_14: J9.2, J13.6, U1.12 (IO14)
IO_15: J10.2, J13.7, U1.35 (IO15)
IO_27: J11.2, J13.8, U1.11 (IO27)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: D4.1 (K), R4.1
unnamed: SW1.4 (A), U1.2 (EN)
unnamed: SW2.1 (A), U3.1 (I1)
unnamed: SW3.1 (A), U3.2 (I2)
unnamed: SW4.1 (A), U3.3 (I3)
unnamed: SW5.1 (A), U3.4 (I4)
unnamed: U1.22 (IO22), U2.4 (RXD)
unnamed: U1.21 (IO23), U2.1 (TXD)
UART1_RX: J2.4, U1.7 (IO32)
UART1_TX: J2.3, U1.8 (IO33)
UART2_RX: J3.4, U1.9 (IO25)
UART2_TX: J3.3, U1.10 (IO26)

Board: 2 copper layers, 100.0 x 70.0 mm, 40 parts (0 on the bottom side), 43 nets.

Other parts of the board:
 : holeφ3.2
 #2,  #3,  #4: holeφ3.2

## Commit log

2024-08-30 線の太さ・ビアの大きさを修正。
2024-08-30 不要データを削除。
2024-08-30 基板サイズを変更。
2024-08-30 綴りを変更。
2024-08-30 コンデンサの容量を変更。
2024-09-03 ガーバーファイルを追加。
2024-09-03 3.2ネジ穴の位置を修正。
2024-09-03 出力zipを除外。
2024-09-18 CANトランシーバのフットプリントを修正。 パスコンの位置を修正。 配線を修正。
2024-10-17 タクトスイッチの向きを修正。 直角配線を撲滅。 上部GPIO3ピンコネクタの向きを修正。
2025-03-17 doc: ドキュメント類を作成。
